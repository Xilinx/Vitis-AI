base-trd-platform