FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-hdmitx-Workaround-for-Versal-display-not-coming-up-o.patch"
