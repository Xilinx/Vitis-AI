COMPATIBLE_MACHINE_versal = ".*"
RDEPENDS_${PN}_remove = "dnndk"

RDEPENDS_${PN}-dev += "\
    vitis-ai-library-dev \
    "
